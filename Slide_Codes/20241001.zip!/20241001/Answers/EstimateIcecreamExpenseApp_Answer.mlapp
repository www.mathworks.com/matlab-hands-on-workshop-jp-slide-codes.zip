classdef EstimateIcecreamExpenseApp_Answer < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        UIFigure              matlab.ui.Figure
        GridLayout            matlab.ui.container.GridLayout
        Panel_4               matlab.ui.container.Panel
        Button                matlab.ui.control.Button
        Panel_6               matlab.ui.container.Panel
        AveHumiditySpinner    matlab.ui.control.Spinner
        Label_6               matlab.ui.control.Label
        PrecipitationSpinner  matlab.ui.control.Spinner
        mmSpinnerLabel        matlab.ui.control.Label
        Panel_5               matlab.ui.container.Panel
        Label_AveTemp         matlab.ui.control.Label
        Label_MinTemp         matlab.ui.control.Label
        Label_MaxTemp         matlab.ui.control.Label
        Label_MaxTempTitle    matlab.ui.control.Label
        Label_MinTempTitle    matlab.ui.control.Label
        MaxMinTempSlider      matlab.ui.control.RangeSlider
        AveTempSlider         matlab.ui.control.Slider
        Label_10              matlab.ui.control.Label
        DatePicker            matlab.ui.control.DatePicker
        Label_12              matlab.ui.control.Label
        Panel_3               matlab.ui.container.Panel
        Label_Yen             matlab.ui.control.Label
        IceEstValue           matlab.ui.control.Label
        IceEstLabel           matlab.ui.control.Label
        Panel_2               matlab.ui.container.Panel
        Label_Title           matlab.ui.control.Label
        IceImage              matlab.ui.control.Image
    end

    
    properties (Access = private)
        RegressionModel % 回帰モデル
        JpHolidays % 日本のカレンダー休日
    end
    

    % Callbacks that handle component events
    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            % 回帰モデルの読み込み
            try 
                %% タスク1　regressionModel.matを読み込む
                load('regressionModel.mat')

                %%
                app.RegressionModel = trainedModel;
            catch ME
                disp(ME)
            end

            % 最高気温、最低気温、平均気温のラベル表記
            MaxMinTempSliderValueChanged(app)
            AveTempSliderValueChanged(app)

            % 休日情報の読み込み (09/01 ~ 10/31)
            jpHolidays = ["09/01" "09/07" "09/08" "09/14" "09/15" "09/16" ...
                "09/21" "09/22" "09/23" "09/28" "09/29" "10/05" "10/06" ...
                "10/12" "10/13" "10/14" "10/19" "10/20" "10/26" "10/27"];
            app.JpHolidays = datetime("2024/" + jpHolidays);
        end

        % Button pushed function: Button
        function ButtonPushed(app, event)
            inputTbl = table(app.AveTempSlider.Value, app.MaxMinTempSlider.Value(2), app.MaxMinTempSlider.Value(1), ...
                app.AveHumiditySpinner.Value, app.PrecipitationSpinner.Value, ismember(app.DatePicker.Value, app.JpHolidays), ...
                'VariableNames', ["平均気温 [℃]", "最高気温 [℃]", "最低気温 [℃]", "平均湿度 [%]", "降水量合計 [mm]", "休日"]);       
            
            %% タスク2　回帰モデルにinputTbl を入力して支出額を予測
            iceEst = app.RegressionModel.predictFcn(inputTbl);
            
            %%
            % ラベルの文字の変更
            app.IceEstValue.Text = sprintf("%.1f", iceEst);
        end

        % Value changed function: MaxMinTempSlider
        function MaxMinTempSliderValueChanged(app, event)
            app.Label_MaxTemp.Text = num2str(app.MaxMinTempSlider.Value(2));
            app.Label_MinTemp.Text = num2str(app.MaxMinTempSlider.Value(1));            
        end

        % Value changed function: AveTempSlider
        function AveTempSliderValueChanged(app, event)
            app.Label_AveTemp.Text = num2str(app.AveTempSlider.Value);
        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            % Get the file path for locating images
            pathToMLAPP = fileparts(mfilename('fullpath'));
            app.UIFigure = uifigure('Visible', 'off');
            app.UIFigure.Name = 'MATLAB App';
            app.GridLayout = uigridlayout(app.UIFigure);
            app.Panel_2 = uipanel(app.GridLayout);
            app.IceImage = uiimage(app.Panel_2);
            app.IceImage.ImageSource = fullfile(pathToMLAPP, 'icecream_icon.png');
            app.Label_Title = uilabel(app.Panel_2);
            app.Label_Title.Text = 'アイスクリームの支出額を予測';
            app.Panel_3 = uipanel(app.GridLayout);
            app.IceEstLabel = uilabel(app.Panel_3);
            app.IceEstLabel.Text = '支出額の予測値';
            app.IceEstValue = uilabel(app.Panel_3);
            app.IceEstValue.Text = '';
            app.Label_Yen = uilabel(app.Panel_3);
            app.Label_Yen.Text = '円';
            app.Panel_4 = uipanel(app.GridLayout);
            app.Label_12 = uilabel(app.Panel_4);
            app.Label_12.Text = '日付を選択';
            app.DatePicker = uidatepicker(app.Panel_4);
            app.DatePicker.Limits = [datetime([2024 9 1]) datetime([2024 10 31])];
            app.DatePicker.DisplayFormat = 'uuuu/MM/dd';
            app.DatePicker.Value = datetime([2024 10 1]);
            app.Panel_5 = uipanel(app.Panel_4);
            app.Label_10 = uilabel(app.Panel_5);
            app.Label_10.Text = '平均気温 [℃]';
            app.AveTempSlider = uislider(app.Panel_5);
            app.AveTempSlider.Limits = [0 40];
            app.AveTempSlider.ValueChangedFcn = createCallbackFcn(app, @AveTempSliderValueChanged, true);
            app.AveTempSlider.Value = 20;
            app.MaxMinTempSlider = uislider(app.Panel_5, 'range');
            app.MaxMinTempSlider.Limits = [0 40];
            app.MaxMinTempSlider.ValueChangedFcn = createCallbackFcn(app, @MaxMinTempSliderValueChanged, true);
            app.MaxMinTempSlider.Step = 1;
            app.MaxMinTempSlider.Value = [18 25];
            app.Label_MinTempTitle = uilabel(app.Panel_5);
            app.Label_MinTempTitle.Text = '最低気温 [℃]';
            app.Label_MaxTempTitle = uilabel(app.Panel_5);
            app.Label_MaxTempTitle.Text = '最高気温 [℃]';
            app.Label_MaxTemp = uilabel(app.Panel_5);
            app.Label_MaxTemp.Text = '';
            app.Label_MinTemp = uilabel(app.Panel_5);
            app.Label_MinTemp.Text = '';
            app.Label_AveTemp = uilabel(app.Panel_5);
            app.Label_AveTemp.Text = '';
            app.Panel_6 = uipanel(app.Panel_4);
            app.mmSpinnerLabel = uilabel(app.Panel_6);
            app.mmSpinnerLabel.Text = '降水量 [mm]';
            app.PrecipitationSpinner = uispinner(app.Panel_6);
            app.PrecipitationSpinner.Limits = [0 Inf];
            app.Label_6 = uilabel(app.Panel_6);
            app.Label_6.Text = '平均湿度 [%]';
            app.AveHumiditySpinner = uispinner(app.Panel_6);
            app.AveHumiditySpinner.Limits = [0 100];
            app.AveHumiditySpinner.Value = 60;
            app.Button = uibutton(app.Panel_4, 'push');
            app.Button.ButtonPushedFcn = createCallbackFcn(app, @ButtonPushed, true);
            app.Button.Text = '予測';
            % Show the figure after all components are created
            app.UIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = EstimateIcecreamExpenseApp_Answer

            % Create UIFigure and components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.UIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.UIFigure)
        end
    end
end